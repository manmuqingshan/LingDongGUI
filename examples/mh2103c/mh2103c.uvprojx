# Keil uVision project mh2103c.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mh2103c
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,IP=IPR
  c include: .\user;.\Libraries\MH210xLib\inc;.\Libraries\MH210xLib\lib;.\user\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c
  group lib/lib
    ./Libraries/MH210xLib/lib/: mh2103.lib
    ./Libraries/MH210xLib/src/: mh210x_adc.c mh210x_bkp.c mh210x_can.c mh210x_crc.c mh210x_dac.c mh210x_dbgmcu.c mh210x_dma.c mh210x_exti.c mh210x_flash.c mh210x_fsmc.c mh210x_gpio.c mh210x_i2c.c mh210x_iwdg.c mh210x_otp.c mh210x_pwr.c mh210x_rcc.c mh210x_rtc.c mh210x_sdio.c mh210x_spi.c mh210x_tim.c mh210x_trng.c mh210x_usart.c mh210x_wwdg.c misc.c system_mh210x.c
  group lib/core
    ./Libraries/CORE/: startup_mh210x.s
  group user/driver
    ./user/driver/: st7789v16bit.c knob.c
software components: Acceleration:Arm-2D Extras:Controls 1.8.3, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.6.2, Acceleration:Arm-2D Helper:PFB 2.1.8, Acceleration:Arm-2D:Alpha-Blending 1.1.7, Acceleration:Arm-2D:Core 1.2.4-dev, Acceleration:Arm-2D:Filter 1.1.7, Acceleration:Arm-2D:Transform 1.1.7, CMSIS:CORE 6.0.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.3.3, LingDongGui Demo:startup 1.0.0, LingDongGui:ldgui 0.8.1
